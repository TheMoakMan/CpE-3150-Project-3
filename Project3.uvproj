# Keil uVision project Project3.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LPC932A1 NXP
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM (0-0x1FF) CLOCK(12000000) MODP2
  output: Project3
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Project3.c uart.c frequency.c
